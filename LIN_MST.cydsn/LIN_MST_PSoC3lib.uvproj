# Keil uVision project LIN_MST_PSoC3lib.uvproj, settings and files
target Debug (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: LIN_MST_PSoC3lib (library)
  c flags: Optimize=2
  c define: DEBUG
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm define: DEBUG
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: CODE RU RC(10) IX CL(XDATA(X:0x0000-X:0x0FFF)) CL(CODE(C:0x0000-C:0x7FFF)) CL(CONST(C:0x0000-C:0x7FFF))
  group Source Files
    ./Generated_Source/PSoC3/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicekeil.inc cydevice_trm.h cydevicekeil_trm.inc cyfitterkeil.inc cyfitter.h cydisabledsheets.h LIN.c LIN.h LIN_PM.c LIN_INT.c LIN_BOOT.c uart_tx_isr.c uart_tx_isr.h uart_rx_isr.c uart_rx_isr.h LIN_Timer.c LIN_Timer.h LIN_Timer_PM.c timer_clock.c timer_clock.h lin_timer_isr.c lin_timer_isr.h LIN_IntClock.c LIN_IntClock.h CyBootAsmKeil.a51 CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cymem.a51 cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c PSoC3_8051.h PSoC3_8051.inc project.h UART_PS2.c UART_PS2.h UART_PS2_PM.c UART_PS2_INT.c UART_PS2_BOOT.c ISR_PS2.c ISR_PS2.h Clock_1.c Clock_1.h isr_1.c isr_1.h UART_PS2_IntClock.c UART_PS2_IntClock.h UART_1.c UART_1.h UART_1_PM.c UART_1_INT.c UART_1_BOOT.c UART_1_IntClock.c UART_1_IntClock.h isr_2.c isr_2.h Clock_2.c Clock_2.h SW_1.c SW_1.h SW_1_aliases.h SW_2.c SW_2.h SW_2_aliases.h Arm.c Arm.h Arm_aliases.h
target Release (MCS-51)
  device: CY8C3245AXI-158 Cypress
  cpu: "IRAM(0x00-0xFF) IROM(0x0-0x7FFF) CLOCK(50000000) MODDP2"
  output: LIN_MST_PSoC3lib (library)
  c flags: Optimize=8
  c misc: PR(${OutputDir}/${CompileFile}.lst) CD MODDP2
  c include: .;.\Generated_Source\PSoC3
  asm misc: NOCO PR(${OutputDir}/${CompileFile}.lst) CASE EP
  asm include: .;.\Generated_Source\PSoC3
  link misc: as above
